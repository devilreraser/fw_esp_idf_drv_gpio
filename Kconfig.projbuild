## Kconfig.projbuild
```kconfig
menu "Component drv_gpio Configuration"

    config DRV_GPIO_USE
        bool "Use drv_gpio component"
        default y
        
endmenu
```
